## src/Kconfig
```kconfig
config HFSPLUS_JOURNAL
	tristate "HFSPLUS filesystem with journal support"
	select NLS
	select NLS_UTF8
	help
		Enabling journal support in HFSPlus file system.
```
